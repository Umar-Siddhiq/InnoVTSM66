# Keil uVision project M031Boot.uvproj, settings and files
target Bootloader (6160000::V6.16::ARMCLANG)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: M031Boot +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\M031\Include;..\..\Library\StdDriver\inc;..\Header;..\Keil;..\Keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../Library/StdDriver/src/: retarget.c uart.c clk.c fmc.c sys.c spi.c gpio.c
  group Source
    ../Source/: main.c Hardware.c Boot.c FMCUser.c W25Qxx.c
  group Header
    ../Header/: Boot.h Hardware.h FMCUser.h W25Qxx.h
